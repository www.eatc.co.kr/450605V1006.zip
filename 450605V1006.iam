# Autodesk Inventor assembly: 450605V1006
## iProperties
Created: 2015-06
Part Number: 450605V1006
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
